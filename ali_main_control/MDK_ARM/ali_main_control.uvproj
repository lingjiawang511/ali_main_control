# Keil uVision project ali_main_control.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ali_main_control +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\include;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\USER\delay;..\USER\led;..\BSP\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c crc16.c stm32f10x_it.c TIM.C usart.c belt.c key_and_light.c roll_paper.c printer.c air_cylinder.c communication.c baffle.c
    ../USER/delay/: delay.c
    ../USER/led/: led.c
    ../BSP/EXTI/: exti.c
  group LIBRARIES
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group remark
    ../: 调试备注.txt
